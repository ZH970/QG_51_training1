# Keil uVision project week3.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: week3 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Conf_tny.A51
    ./Header/: Delay.h Timer0.h Nixie.h
    ./Sources/: Delay.c main.c Timer0.c Nixie.c
